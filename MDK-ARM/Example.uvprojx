# Keil uVision project Example.uvprojx, settings and files
target EatWhat (6230000::V6.23::ARMCLANG)
  device: FM33FK54X FMSH
  pack: FMSH.FM33FK5XX_DFP.1.0.2
  cpu: IRAM(0x20000000,0xC000) IROM(0x00000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: FM33FK5XX,USE_FULL_ASSERT,__USE_ICACHE
  c include: ../Drivers/CMSIS/Device/FM/FM33xx/Include;../Inc;../MF-config/Inc;../Drivers/FM33FK5xx_FL_Driver/Inc;..\Middlewares\FATFS\source;..\Drivers\BSP\Inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable;..\Middlewares\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\FM33FK54XX.sct
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33fk5xx.S
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c touch.c hardware_test.c bsp.c myff.c recorder.c wav.c mytasks.c rtc.c
  group Dirvers/BSP
    ../Drivers/BSP/Src/: lcd.c gt911.c i2csmb.c sd_driver.c w25q64.c uart.c sleep.c misc.c font.c dma.c i2s.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33fk5xx.c
  group Drivers/FM33FK5xx_FL_Driver
    ../Drivers/FM33FK5xx_FL_Driver/Src/: fm33fk5xx_fl.c fm33fk5xx_fl_adc.c fm33fk5xx_fl_aes.c fm33fk5xx_fl_atim.c fm33fk5xx_fl_bstim16.c fm33fk5xx_fl_can.c fm33fk5xx_fl_cmu.c fm33fk5xx_fl_comp.c fm33fk5xx_fl_crc.c fm33fk5xx_fl_dac.c fm33fk5xx_fl_dma.c fm33fk5xx_fl_epsc.c fm33fk5xx_fl_epwm.c fm33fk5xx_fl_exti.c fm33fk5xx_fl_gpio.c fm33fk5xx_fl_gptim.c fm33fk5xx_fl_i2c_master.c fm33fk5xx_fl_i2c_smbus.c fm33fk5xx_fl_iwdt.c fm33fk5xx_fl_lptim16.c fm33fk5xx_fl_lpuart.c fm33fk5xx_fl_opa.c fm33fk5xx_fl_pgl.c fm33fk5xx_fl_pmu.c fm33fk5xx_fl_rng.c fm33fk5xx_fl_rtcb.c fm33fk5xx_fl_spi.c fm33fk5xx_fl_svd.c fm33fk5xx_fl_u7816.c fm33fk5xx_fl_uart.c fm33fk5xx_fl_vao.c fm33fk5xx_fl_wwdt.c fm33fk5xx_fl_flash.c
  group Middlewares/FATFS
    ../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c myffunicode.c
  group Middlewares/FreeRTOS/code
    ../Middlewares/FreeRTOS/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c
  group Middlewares/FreeRTOS/portable
    ../Middlewares/FreeRTOS/portable/: heap_4.c port.c portasm.c
  group Middlewares/GUI
    ../Middlewares/GUI/: GUI_APP.c ugui.c
